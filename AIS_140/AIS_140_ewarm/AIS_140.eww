<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\project\AIS_140.ewp</path>
    </project>
</workspace>