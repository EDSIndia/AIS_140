# IAR project AIS_140.ewp, settings and files
configuration debug (ARM, debug)
  General.CoreVariant: 61
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.OGChipSelectEditMenu: Default None
  General.FPU2: 0
  ICCARM.CCDefines: STM32C532xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: user_modifiable/_debug_IAR_STM32C532RCT6/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../arch/cmsis/CMSIS/Core/Include; ../stm32c5xx_dfp/Include; ../stm32c5xx_drivers/hal; ../stm32c5xx_drivers/ll; ../stm32c5xx_drivers/timebases; generated/hal; user_modifiable/_debug_IAR_STM32C532RCT6; E:\Jeevan\PROJECTS_EDS\AIS_140\Firmware\AIS_140\AIS_140_ewarm\project\Core\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: STM32C532xx; _RTE_
  AARM.AUserIncludes: ; ../arch/cmsis/CMSIS/Core/Include; ../stm32c5xx_dfp/Include; ../stm32c5xx_drivers/hal; ../stm32c5xx_drivers/ll; ../stm32c5xx_drivers/timebases; generated/hal; user_modifiable/_debug_IAR_STM32C532RCT6
  OBJCOPY.OOCOutputFile: AIS_140.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: user_modifiable/Device/STM32C532RCT6/stm32c53xxc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Core
    Core/Src/: App_RAM.c main.c STM32_Config.c
  group generated/hal
    generated/hal/: mx_adc1.c mx_adc1.h mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_fdcan1.c mx_fdcan1.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_iwdg.c mx_iwdg.h mx_rcc.c mx_rcc.h mx_rtc.c mx_rtc.h mx_spi1.c mx_spi1.h mx_spi2.c mx_spi2.h mx_system.c mx_system.h mx_uart4.c mx_uart4.h mx_usart1.c mx_usart1.h mx_usart2.c mx_usart2.h stm32_external_env.h stm32_ll.h stm32c5xx_hal_conf.h
  group stm32c5xx_dfp
    ../stm32c5xx_dfp/: README.md
  group stm32c5xx_dfp/Include
    ../stm32c5xx_dfp/Include/: stm32c5xx.h
  group stm32c5xx_drivers
    ../stm32c5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32c5xx_drivers/doc
    ../stm32c5xx_drivers/doc/: STMicroelectronics.stm32c5xx_hal_drivers_dependencies.md
  group stm32c5xx_drivers/hal
    ../stm32c5xx_drivers/hal/: stm32_hal.h stm32c5xx_hal.c stm32c5xx_hal.h stm32c5xx_hal_adc.c stm32c5xx_hal_adc.h stm32c5xx_hal_cortex.c stm32c5xx_hal_cortex.h stm32c5xx_hal_def.h stm32c5xx_hal_dma.c stm32c5xx_hal_dma.h stm32c5xx_hal_fdcan.c stm32c5xx_hal_fdcan.h stm32c5xx_hal_flash.c stm32c5xx_hal_flash.h stm32c5xx_hal_flash_itf.c stm32c5xx_hal_flash_itf.h stm32c5xx_hal_gpio.c stm32c5xx_hal_gpio.h stm32c5xx_hal_icache.c stm32c5xx_hal_icache.h stm32c5xx_hal_iwdg.c stm32c5xx_hal_iwdg.h stm32c5xx_hal_pwr.c stm32c5xx_hal_pwr.h stm32c5xx_hal_q.c stm32c5xx_hal_q.h stm32c5xx_hal_rcc.c stm32c5xx_hal_rcc.h stm32c5xx_hal_rtc.c stm32c5xx_hal_rtc.h
  group stm32c5xx_drivers/ll
    ../stm32c5xx_drivers/ll/: stm32c5xx_ll_adc.h stm32c5xx_ll_bus.h stm32c5xx_ll_dbgmcu.h stm32c5xx_ll_dma.h stm32c5xx_ll_exti.h stm32c5xx_ll_flash.h stm32c5xx_ll_gpio.h stm32c5xx_ll_icache.h stm32c5xx_ll_iwdg.h stm32c5xx_ll_pwr.h stm32c5xx_ll_rcc.h stm32c5xx_ll_rtc.h stm32c5xx_ll_sbs.h stm32c5xx_ll_spi.h stm32c5xx_ll_usart.h stm32c5xx_ll_utils.h
  group user_modifiable/Device/STM32C532RCT6
    user_modifiable/Device/STM32C532RCT6/: startup_stm32c532xx.c system_stm32c5xx.c
